# Keil uVision project PowerDemo.uvprojx, settings and files
target ULINKplus (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1857 NXP
  pack: Keil.LPC1800_DFP.2.8.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PowerDemo
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=177
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: main.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:Event Recorder 1.2.1, Board Support:A/D Converter 1.0.0, Board Support:Buttons 1.0.0, Board Support:Graphic LCD 1.0.0, Board Support:LED 1.0.0, CMSIS Driver:SPI:SSP 2.9.0, Device:GPDMA 1.3.0, Device:GPIO 1.0.0, Device:SCU 1.1.0, Device:Startup 1.0.0

# Keil uVision project DSP_Sine_Wave.uvprojx, settings and files
target LPC1857 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1857 NXP (founded by Philips)
  pack: Keil.LPC1800_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  AfterMake: $K\ARM\BIN\ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM3
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Files
    ./: sine_generator.c low_pass_filter.c DirtyFilter.c
  group Documentation
    ./: Abstract.txt
target LPC1857 RAM (ARM-ADS)
  device: LPC1857 NXP (founded by Philips)
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS2:Keil RTX5 5.1.0, Compiler:Event Recorder 1.1.0, Device:GPIO 1.0, Device:SCU 1.1, Device:Startup 1.0.0
